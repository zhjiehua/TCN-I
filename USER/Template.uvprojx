# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_FreeRTOS +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\FreeRTOS\Source\CMSIS_RTOS;..\FWLIB\CMSIS\Include;..\HARDWARE;..\HARDWARE\24CXX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/Button/: Button.c
    ../HARDWARE/DCMotor/: DCMotor.c
    ../HARDWARE/PhotoelectricSensor/: PhSensor.c
    ../HARDWARE/RelayMOS/: RelayMOS.c
    ../HARDWARE/StepMotor/: StepMotor.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/NTCResistor/: adc.c NTCResistor.c
    ../HARDWARE/Timer/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_dma.c
  group FreeRTOS
    ../FreeRTOS/Source/: event_groups.c croutine.c tasks.c list.c timers.c queue.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group HMI
    ../HMI/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c
  group Logic
    ../Logic/: managerment.c project.c misc.c
  group UILogic
    ../UILogic/: mainPage.c manualPage.c parameterPage.c inputPage.c aboutPage.c statusPage.c tempparaPage.c timeparaPage.c manualrawPage.c motorparaPage.c setupPage.c permitPage.c
  group PID
    ../PID/: PID.c
